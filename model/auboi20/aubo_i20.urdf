Commit message: add pinocchio interface

File: model/auboi20/aubo_i20.urdf (robot description, URDF)
Before this commit: robot aubo_i20, 8 links, 7 joints
Joints:
- joint joint0: origin xyz=0 0 0.1855 rpy=0 0 3.1415926535897932384626433832795 -> xyz=0 0 0.1855 rpy=0 0 0
